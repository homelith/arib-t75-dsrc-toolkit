<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>etc2pcap_20m_dual</value></param>
<param><key>author</key><value>homelith</value></param>
<param><key>description</key><value>demod ETC signal, detect packet and output to pcap</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>etc2pcap_20m_dual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5800000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch0_shift</value></param>
<param><key>value</key><value>-5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch1_shift</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lna_gain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>15000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>update_period</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-ch0_shift</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-ch1_shift</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ask_dec_0</value></param>
<param><key>_source_code</key><value>#-------------------------------------------------------------------------------
# ask_dec.py
#   ARIB STD-T75 ASK packet extractor design for Embedded Python Block
#-------------------------------------------------------------------------------

#-------------------------------------------------------------------------------
# MIT License
#
# Copyright (c) 2020 chibiegg
#
# Permission is hereby granted, free of charge, to any person obtaining a copy
# of this software and associated documentation files (the "Software"), to deal
# in the Software without restriction, including without limitation the rights
# to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
# copies of the Software, and to permit persons to whom the Software is
# furnished to do so, subject to the following conditions:
#
# The above copyright notice and this permission notice shall be included in all
# copies or substantial portions of the Software.
#
# THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
# IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
# FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
# AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
# LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
# OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
# SOFTWARE.
#-------------------------------------------------------------------------------

import numpy as np
import sys
import struct
import pmt
from gnuradio import gr

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    MODE_IDLE     = 0
    MODE_PREAMBLE = 1
    MODE_FRAME    = 2
    EDGE_POSITIVE = 0
    EDGE_NEGATIVE = 1

    SUBTICKS_PER_TICK = 4

    def __init__(self, module_name="ask_ch0", ticks_per_symbol=19.5, tps_deviation=4.0, lower_threshold=0.38, upper_threshold=0.42, sample_rate=20000000, file_name="C:/Users/user/Desktop/ch0.pcap"):
        gr.sync_block.__init__(
            self,
            name='ARIB STD-T75 ASK packet extractor',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

        # store argument
        self.module_name = module_name
        self.subticks_per_symbol = int(ticks_per_symbol * self.SUBTICKS_PER_TICK)
        self.stps_deviation = int(tps_deviation * self.SUBTICKS_PER_TICK)
        self.lower_threshold = lower_threshold
        self.upper_threshold = upper_threshold
        self.sample_rate = sample_rate
        self.file_name = file_name

        # initialize internal state
        self.mode = self.MODE_IDLE

        self.subticks_from_prev_edge = self.subticks_per_symbol + self.stps_deviation
        self.ticks_global = 0
        self.prev_value = 0
        self.preamble_counter = 0

        self.pkt_buf = bytearray(65535)
        self.ticks_pkt_arrival = 0
        self.pkt_len = 0
        self.byte_buf = 0x00
        self.bit_pack_count = 0
        self.pkt_processed = 0
        self.residual_offset = 0
        self.reset_count = 0

        self.prev_bin_val = 0

        self.global_header_written = False

    def flushpkt(self):

        # output packet header
        with open(self.file_name, "ab") as f:
            usec = float(self.ticks_pkt_arrival) / (self.sample_rate / 1000000.0)
            f.write(struct.pack(
                "&lt;LLLL",
                int(usec/1000000.0),
                int(usec%1000000.0),
                self.pkt_len,
                self.pkt_len,
            ))

            # output pkt bytes
            f.write(self.pkt_buf[0:self.pkt_len])

        # show log
        self.pkt_processed += 1
        print("%s : %d th packet processed (time=%f, len=%d, resisual_offset=%d) " % (self.module_name, self.pkt_processed, usec, self.pkt_len, self.residual_offset))

    def resetsubtick(self, tune):
        if self.subticks_from_prev_edge &lt; self.subticks_per_symbol:
            self.subticks_from_prev_edge -= (self.subticks_per_symbol - tune)
            self.residual_offset -= 1
        else:
            self.subticks_from_prev_edge -= (self.subticks_per_symbol + tune)
            self.residual_offset += 1

    def addbit(self, value):
        # pack bit with LSB-first bit order
        b = 0
        if value != 0:
            b = 0x80
        self.byte_buf = (self.byte_buf &gt;&gt; 1) &amp; 0x7f
        self.byte_buf = self.byte_buf | b

        if self.bit_pack_count == 7:
            # completed 1 byte and store into pkt buf
            self.pkt_buf[self.pkt_len] = self.byte_buf
            self.bit_pack_count = 0
            self.pkt_len += 1
        else:
            self.bit_pack_count += 1

    def work(self, input_items, output_items):

        # write pcap global header on only first call of this function
        if self.global_header_written == False:

            with open(self.file_name, "wb") as f:
                f.write(struct.pack(
                    "&lt;LHHLLLL",
                    0xa1b2c3d4, # magic number
                    2, # major version number
                    4, # minor version number
                    0, # GMT to local correction
                    0, # accuracy of timestamps
                    65535, # max length of captured packets, in octets
                    0, # data link type (LINKTYPE_NULL)
                ))
                self.global_header_written = True


        # if there is multiple input items queued, consume all of them
        idx = -1
        for real_val in input_items[0]:
            idx += 1

            # convert float input into int with histerisis
            if self.prev_bin_val == 0:
                if real_val &gt;= self.upper_threshold:
                    bin_val = 1
                else:
                    bin_val = 0
            else:
                if real_val &lt; self.lower_threshold:
                    bin_val = 0
                else:
                    bin_val = 1

            # elapse global time ticks
            self.ticks_global += 1

            if self.mode != self.MODE_IDLE:

                # elapse local ticks only when state is not IDLE
                self.subticks_from_prev_edge += self.SUBTICKS_PER_TICK

                if self.subticks_from_prev_edge &gt; (self.subticks_per_symbol + self.stps_deviation):
                    # edge detection timeout drives internal state reset

                    if self.mode == self.MODE_FRAME:
                        # recovery from MODE_FRAME state flush pkt buffer to output
                        self.flushpkt()
                        self.mode = self.MODE_IDLE
                    else:
                        self.mode = self.MODE_IDLE

            # processing only occurs where value transition detected
            if self.prev_bin_val == bin_val:
                continue
            self.prev_bin_val = bin_val

            #-----------------------------------------------------------------------
            # branch process based on MODE_ value

            if self.mode == self.MODE_IDLE and bin_val == 0:
                # while waiting preamble (first negative edge)
                self.mode = self.MODE_PREAMBLE
                self.subticks_from_prev_edge = 0
                self.preamble_counter = 1
                self.pkt_len = 0
                self.residual_offset = 0
                self.reset_count = 0
                self.bit_pack_count = 0

            elif self.mode == self.MODE_PREAMBLE:
                # while decoding preamble

                # too fast arrival of next edge reset internal state
                if self.subticks_from_prev_edge &lt; (self.subticks_per_symbol - self.stps_deviation):
                    self.mode = self.MODE_IDLE
                    continue

                # accept expected edge until preamble counter reaches 15
                if self.preamble_counter &lt; 15:
                    self.preamble_counter += 1
                    self.resetsubtick(2)
                    continue

                # preamble counter 15 drives state into MODE_FRAME
                self.mode = self.MODE_FRAME
                self.resetsubtick(2)
                self.ticks_pkt_arrival = self.ticks_global

                # add tags for trigger
                self.add_item_tag(0, self.nitems_written(0) + idx, pmt.intern("startofpacket"), pmt.intern("1"))

            elif self.mode == self.MODE_FRAME:
                # while receiving a frame

                # before acceptable tps_deviation range, ignore first edge detected but issue reset on second edge detected
                if self.subticks_from_prev_edge &lt; (self.subticks_per_symbol - self.stps_deviation):
                    if self.reset_count == 0:
                        self.reset_count = 1
                        continue
                    else:
                        self.flushpkt()
                        self.mode = self.MODE_IDLE
                        continue

                # accept the edge detected
                if bin_val == 0:
                    self.addbit(1)
                else:
                    self.addbit(0)
                self.resetsubtick(1)
                self.reset_count = 0


        output_items[0][:] = input_items[0]
        return len(input_items[0])

</value></param>
<param><key>file_name</key><value>'C:/work/ch0.pcap'</value></param>
<param><key>lower_threshold</key><value>0.38</value></param>
<param><key>module_name</key><value>'ask_ch0'</value></param>
<param><key>sample_rate</key><value>15000000</value></param>
<param><key>ticks_per_symbol</key><value>14.5</value></param>
<param><key>tps_deviation</key><value>4.0</value></param>
<param><key>upper_threshold</key><value>0.42</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ask_dec_1</value></param>
<param><key>_source_code</key><value>#-------------------------------------------------------------------------------
# ask_dec.py
#   ARIB STD-T75 ASK packet extractor design for Embedded Python Block
#-------------------------------------------------------------------------------

#-------------------------------------------------------------------------------
# MIT License
#
# Copyright (c) 2020 chibiegg
#
# Permission is hereby granted, free of charge, to any person obtaining a copy
# of this software and associated documentation files (the "Software"), to deal
# in the Software without restriction, including without limitation the rights
# to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
# copies of the Software, and to permit persons to whom the Software is
# furnished to do so, subject to the following conditions:
#
# The above copyright notice and this permission notice shall be included in all
# copies or substantial portions of the Software.
#
# THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
# IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
# FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
# AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
# LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
# OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
# SOFTWARE.
#-------------------------------------------------------------------------------

import numpy as np
import sys
import struct
import pmt
from gnuradio import gr

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    MODE_IDLE     = 0
    MODE_PREAMBLE = 1
    MODE_FRAME    = 2
    EDGE_POSITIVE = 0
    EDGE_NEGATIVE = 1

    SUBTICKS_PER_TICK = 4

    def __init__(self, module_name="ask_ch1", ticks_per_symbol=19.5, tps_deviation=4.0, lower_threshold=0.38, upper_threshold=0.42, sample_rate=20000000, file_name="C:/Users/user/Desktop/ch1.pcap"):
        gr.sync_block.__init__(
            self,
            name='ARIB STD-T75 ASK packet extractor',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

        # store argument
        self.module_name = module_name
        self.subticks_per_symbol = int(ticks_per_symbol * self.SUBTICKS_PER_TICK)
        self.stps_deviation = int(tps_deviation * self.SUBTICKS_PER_TICK)
        self.lower_threshold = lower_threshold
        self.upper_threshold = upper_threshold
        self.sample_rate = sample_rate
        self.file_name = file_name

        # initialize internal state
        self.mode = self.MODE_IDLE

        self.subticks_from_prev_edge = self.subticks_per_symbol + self.stps_deviation
        self.ticks_global = 0
        self.prev_value = 0
        self.preamble_counter = 0

        self.pkt_buf = bytearray(65535)
        self.ticks_pkt_arrival = 0
        self.pkt_len = 0
        self.byte_buf = 0x00
        self.bit_pack_count = 0
        self.pkt_processed = 0
        self.residual_offset = 0
        self.reset_count = 0

        self.prev_bin_val = 0

        self.global_header_written = False

    def flushpkt(self):

        # output packet header
        with open(self.file_name, "ab") as f:
            usec = float(self.ticks_pkt_arrival) / (self.sample_rate / 1000000.0)
            f.write(struct.pack(
                "&lt;LLLL",
                int(usec/1000000.0),
                int(usec%1000000.0),
                self.pkt_len,
                self.pkt_len,
            ))

            # output pkt bytes
            f.write(self.pkt_buf[0:self.pkt_len])

        # show log
        self.pkt_processed += 1
        print("%s : %d th packet processed (time=%f, len=%d, resisual_offset=%d) " % (self.module_name, self.pkt_processed, usec, self.pkt_len, self.residual_offset))

    def resetsubtick(self, tune):
        if self.subticks_from_prev_edge &lt; self.subticks_per_symbol:
            self.subticks_from_prev_edge -= (self.subticks_per_symbol - tune)
            self.residual_offset -= 1
        else:
            self.subticks_from_prev_edge -= (self.subticks_per_symbol + tune)
            self.residual_offset += 1

    def addbit(self, value):
        # pack bit with LSB-first bit order
        b = 0
        if value != 0:
            b = 0x80
        self.byte_buf = (self.byte_buf &gt;&gt; 1) &amp; 0x7f
        self.byte_buf = self.byte_buf | b

        if self.bit_pack_count == 7:
            # completed 1 byte and store into pkt buf
            self.pkt_buf[self.pkt_len] = self.byte_buf
            self.bit_pack_count = 0
            self.pkt_len += 1
        else:
            self.bit_pack_count += 1

    def work(self, input_items, output_items):

        # write pcap global header on only first call of this function
        if self.global_header_written == False:

            with open(self.file_name, "wb") as f:
                f.write(struct.pack(
                    "&lt;LHHLLLL",
                    0xa1b2c3d4, # magic number
                    2, # major version number
                    4, # minor version number
                    0, # GMT to local correction
                    0, # accuracy of timestamps
                    65535, # max length of captured packets, in octets
                    0, # data link type (LINKTYPE_NULL)
                ))
                self.global_header_written = True


        # if there is multiple input items queued, consume all of them
        idx = -1
        for real_val in input_items[0]:
            idx += 1

            # convert float input into int with histerisis
            if self.prev_bin_val == 0:
                if real_val &gt;= self.upper_threshold:
                    bin_val = 1
                else:
                    bin_val = 0
            else:
                if real_val &lt; self.lower_threshold:
                    bin_val = 0
                else:
                    bin_val = 1

            # elapse global time ticks
            self.ticks_global += 1

            if self.mode != self.MODE_IDLE:

                # elapse local ticks only when state is not IDLE
                self.subticks_from_prev_edge += self.SUBTICKS_PER_TICK

                if self.subticks_from_prev_edge &gt; (self.subticks_per_symbol + self.stps_deviation):
                    # edge detection timeout drives internal state reset

                    if self.mode == self.MODE_FRAME:
                        # recovery from MODE_FRAME state flush pkt buffer to output
                        self.flushpkt()
                        self.mode = self.MODE_IDLE
                    else:
                        self.mode = self.MODE_IDLE

            # processing only occurs where value transition detected
            if self.prev_bin_val == bin_val:
                continue
            self.prev_bin_val = bin_val

            #-----------------------------------------------------------------------
            # branch process based on MODE_ value

            if self.mode == self.MODE_IDLE and bin_val == 0:
                # while waiting preamble (first negative edge)
                self.mode = self.MODE_PREAMBLE
                self.subticks_from_prev_edge = 0
                self.preamble_counter = 1
                self.pkt_len = 0
                self.residual_offset = 0
                self.reset_count = 0
                self.bit_pack_count = 0

            elif self.mode == self.MODE_PREAMBLE:
                # while decoding preamble

                # too fast arrival of next edge reset internal state
                if self.subticks_from_prev_edge &lt; (self.subticks_per_symbol - self.stps_deviation):
                    self.mode = self.MODE_IDLE
                    continue

                # accept expected edge until preamble counter reaches 15
                if self.preamble_counter &lt; 15:
                    self.preamble_counter += 1
                    self.resetsubtick(2)
                    continue

                # preamble counter 15 drives state into MODE_FRAME
                self.mode = self.MODE_FRAME
                self.resetsubtick(2)
                self.ticks_pkt_arrival = self.ticks_global

                # add tags for trigger
                self.add_item_tag(0, self.nitems_written(0) + idx, pmt.intern("startofpacket"), pmt.intern("1"))

            elif self.mode == self.MODE_FRAME:
                # while receiving a frame

                # before acceptable tps_deviation range, ignore first edge detected but issue reset on second edge detected
                if self.subticks_from_prev_edge &lt; (self.subticks_per_symbol - self.stps_deviation):
                    if self.reset_count == 0:
                        self.reset_count = 1
                        continue
                    else:
                        self.flushpkt()
                        self.mode = self.MODE_IDLE
                        continue

                # accept the edge detected
                if bin_val == 0:
                    self.addbit(1)
                else:
                    self.addbit(0)
                self.resetsubtick(1)
                self.reset_count = 0


        output_items[0][:] = input_items[0]
        return len(input_items[0])

</value></param>
<param><key>file_name</key><value>'C:/work/ch1.pcap'</value></param>
<param><key>lower_threshold</key><value>0.38</value></param>
<param><key>module_name</key><value>'ask_ch1'</value></param>
<param><key>sample_rate</key><value>15000000</value></param>
<param><key>ticks_per_symbol</key><value>14.5</value></param>
<param><key>tps_deviation</key><value>4.0</value></param>
<param><key>upper_threshold</key><value>0.42</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>C:\work\output.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\work\input.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.0078125</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ff_and_fb_agc_0</value></param>
<param><key>backward_samples</key><value>100</value></param>
<param><key>_source_code</key><value>#-------------------------------------------------------------------------------
# ff_and_fb_agc.py
#   feed-forward and feed-back hybrid AGC
#-------------------------------------------------------------------------------

#-------------------------------------------------------------------------------
# MIT License
#
# Copyright (c) 2021 homelith
#
# Permission is hereby granted, free of charge, to any person obtaining a copy
# of this software and associated documentation files (the "Software"), to deal
# in the Software without restriction, including without limitation the rights
# to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
# copies of the Software, and to permit persons to whom the Software is
# furnished to do so, subject to the following conditions:
#
# The above copyright notice and this permission notice shall be included in all
# copies or substantial portions of the Software.
#
# THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
# IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
# FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
# AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
# LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
# OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
# SOFTWARE.
#-------------------------------------------------------------------------------

import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    def __init__(self, forward_samples=100, backward_samples=100, reference=0.8):
        gr.sync_block.__init__(
            self,
            name='FF and FB AGC',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.forward_samples = forward_samples
        self.backward_samples = backward_samples
        self.reference = reference
        self.delay_buffer = [0.0] * (forward_samples + backward_samples + 1)

    def work(self, input_items, output_items):
	oval_array = []
        for ival in input_items[0]:
            self.delay_buffer.append(ival)
            self.delay_buffer = self.delay_buffer[1:]
            gain = self.reference / max(self.delay_buffer)
            oval = self.delay_buffer[self.backward_samples] * gain
            oval_array.append(oval)
        output_items[0][:] = oval_array
        return len(output_items[0])
</value></param>
<param><key>forward_samples</key><value>100</value></param>
<param><key>reference</key><value>0.8</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ff_and_fb_agc_1</value></param>
<param><key>backward_samples</key><value>100</value></param>
<param><key>_source_code</key><value>#-------------------------------------------------------------------------------
# ff_and_fb_agc.py
#   feed-forward and feed-back hybrid AGC
#-------------------------------------------------------------------------------

#-------------------------------------------------------------------------------
# MIT License
#
# Copyright (c) 2021 homelith
#
# Permission is hereby granted, free of charge, to any person obtaining a copy
# of this software and associated documentation files (the "Software"), to deal
# in the Software without restriction, including without limitation the rights
# to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
# copies of the Software, and to permit persons to whom the Software is
# furnished to do so, subject to the following conditions:
#
# The above copyright notice and this permission notice shall be included in all
# copies or substantial portions of the Software.
#
# THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
# IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
# FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
# AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
# LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
# OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
# SOFTWARE.
#-------------------------------------------------------------------------------

import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

    def __init__(self, forward_samples=100, backward_samples=100, reference=0.8):
        gr.sync_block.__init__(
            self,
            name='FF and FB AGC',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.forward_samples = forward_samples
        self.backward_samples = backward_samples
        self.reference = reference
        self.delay_buffer = [0.0] * (forward_samples + backward_samples + 1)

    def work(self, input_items, output_items):
	oval_array = []
        for ival in input_items[0]:
            self.delay_buffer.append(ival)
            self.delay_buffer = self.delay_buffer[1:]
            gain = self.reference / max(self.delay_buffer)
            oval = self.delay_buffer[self.backward_samples] * gain
            oval_array.append(oval)
        output_items[0][:] = oval_array
        return len(output_items[0])
</value></param>
<param><key>forward_samples</key><value>100</value></param>
<param><key>reference</key><value>0.8</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>freq_at_a_glance</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"freq_at_a_glance"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2500000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>2500000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>lna_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>sample_counter</value></param>
<param><key>_source_code</key><value>#-------------------------------------------------------------------------------
# sample_counter.py
#-------------------------------------------------------------------------------

#-------------------------------------------------------------------------------
# MIT License
#
# Copyright (c) 2020 homelith
#
# Permission is hereby granted, free of charge, to any person obtaining a copy
# of this software and associated documentation files (the "Software"), to deal
# in the Software without restriction, including without limitation the rights
# to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
# copies of the Software, and to permit persons to whom the Software is
# furnished to do so, subject to the following conditions:
#
# The above copyright notice and this permission notice shall be included in all
# copies or substantial portions of the Software.
#
# THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
# IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
# FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
# AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
# LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
# OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
# SOFTWARE.
#-------------------------------------------------------------------------------

import numpy as np
from gnuradio import gr

class blk(gr.sync_block):
    def __init__(self, squawk_interval=20000000):
        gr.sync_block.__init__(
            self,
            name='Sample Counter',
            in_sig=[np.complex64],
            out_sig=None
        )
        self.squawk_interval = squawk_interval
        self.tick_count = 0
        self.prev_squawk_count = 0

    def work(self, input_items, output_items):
        self.tick_count += len(input_items[0])
        if int(self.tick_count / self.squawk_interval) != self.prev_squawk_count:
            print("sample counter : %d samples processed" % self.tick_count)
            self.prev_squawk_count = int(self.tick_count / self.squawk_interval)
        return len(input_items[0])
</value></param>
<param><key>squawk_interval</key><value>1000000</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>time_sink_ch0_glance</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"ch0_at_a_glance"</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.00001</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>time_sink_ch0_packet</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"ch0_packet"</value></param>
<param><key>size</key><value>1500</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.00003</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"startofpacket"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>time_sink_ch1_glance</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"ch1_at_a_glance"</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.00001</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>update_period</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>time_sink_ch1_packet</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"ch1_packet"</value></param>
<param><key>size</key><value>1500</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.00003</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"startofpacket"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>update_period</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ask_dec_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ask_dec_0</source_block_id><sink_block_id>time_sink_ch0_packet</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ask_dec_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ask_dec_1</source_block_id><sink_block_id>time_sink_ch1_packet</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>ff_and_fb_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>ff_and_fb_agc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>freq_at_a_glance</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>sample_counter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ff_and_fb_agc_0</source_block_id><sink_block_id>ask_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ff_and_fb_agc_1</source_block_id><sink_block_id>ask_dec_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>time_sink_ch0_glance</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>time_sink_ch1_glance</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
